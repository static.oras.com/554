Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-09-06T12:49:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Sep 06 12:49:15 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{A3400443-704A-41B7-841B-FD894BEEA5ED}\ifc * Database version: 5507 * Database creation date: Fri Sep 06 12:49:11 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Sep 06 12:49:12 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Sep 06 12:49:12 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 554 Shower set, 554:554 Shower set:481840
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - NominalDepth: 128.222 mm; NominalHeight: 760 mm; NominalWidth: 222.173 mm; Pipe Length: 650 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 554; ConvergoRefNr: 0087-1909-0117-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 25/07/2019
Type - Green Building Properties(Type) - Customs Code: 39249000; EAN Number: 6414150088605; EN Standard: EN 1112; LVI Number: 6510218; NRF Number: 4205331; RSK Number: 8320215; VVS Number: 737758734
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/554; Catalog Drawing URL: http://static.oras.com/catdrw/554; Dimension Drawing URL: http://static.oras.com/dimdrw/554; FDV Document URL: http://www.oras.com/datasheet/554/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/554; Group: Hand showers and shower sets; Long Marketing: Oras Apollo Style shower set including hand shower (Ø95) with 3-spray options including EcoFlow control, adjustable max. 720 mm shower rail, 1750 mm shower hose and a soap tray.; Manufacturer: Oras; Model: 554 Shower set; Name_en: 554 Shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 781 x 156 x 55; Package Weight: 1.125 kg; Product Code: 554; Product Datasheet: http://www.oras.com/datasheet/554/en; Product Family: Oras Apollo Style; Product Image URL: http://static.oras.com/image/554; Product URL: http://static.oras.com/554; Type Name: 554 Shower set
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G1/2; Eco Flow At 300kPa: 0.0052972 m3/s; Flow Rate At 300kPa: 0.0105944 m3/s; Hand Shower Size: 96 mm; Installation and Maintenance: http://static.oras.com/manual/554; Installation Type: Wall-mounted; Max. Hot Water Supply: 65 kg/K/s3
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 554; Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 554; Name: 554 Shower set; ReplacementCost: n/a; Shape: Sculptured; Size: 220x130x760 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 554; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 554 Shower set
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.294788 m2; Volume: 0.0216505 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 554: 554 Shower set; Family and Type: 554: 554 Shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 554: 554 Shower set; Type Id: 554: 554 Shower set; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
